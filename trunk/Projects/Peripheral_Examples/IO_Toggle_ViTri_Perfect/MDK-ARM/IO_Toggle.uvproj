# Keil uVision project IO_Toggle.uvproj, settings and files
target IO_Toggle (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: IO_Toggle
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F0308-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group STM32F0308-Discovery
    ./../../../../Utilities/STM32F0308-Discovery/: stm32f0308_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ./../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ./../: main.c stm32f0xx_it.c system_stm32f0xx.c
    ../: F0_USART.c F0_Timer1_PWM.c F0_Timer3_EncoderInterface.c F0_Timer14.c F0_DMA_ADC.c pid.c
